## boards/shields/klocked/Kconfig.defconfig
```kconfig
if SHIELD_KLOCKED

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "klocked"

endif
```
